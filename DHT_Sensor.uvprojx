# Keil uVision project DHT_Sensor.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DHT_Sensor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ../Workspace/Lab UART/: main.c
  group src
    ../Workspace/Lab UART/: EduBase_Button_Interrupt.c GPIO.c PMOD_BTN_Interrupt.c SysTick_Delay.c UART0.c UART1.c
    ./: DHT_22.c
  group inc
    ../Workspace/Lab UART/: UART1.h UART0.h SysTick_Delay.h PMOD_BTN_Interrupt.h GPIO.h EduBase_Button_Interrupt.h
    ./: DHT_22.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
